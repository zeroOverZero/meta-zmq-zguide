# Fix at version 4.5.0 for compatibility with the cppzmq-example recipe
SRCREV = "e67fa0e16d7964876228952f60693f5c03ea0cc1"
PV = "4.5.0+git${SRCPV}"