# Fix at version 4.3.2 for compatibility with the cppzmq-example recipe
SRC_URI[md5sum] = "2047e917c2cc93505e2579bcba67a573"
SRC_URI[sha256sum] = "ebd7b5c830d6428956b67a0454a7f8cbed1de74b3b01e5c33c5378e22740f763"
PV = "4.3.2"